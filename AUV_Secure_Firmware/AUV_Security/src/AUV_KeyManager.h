/*
 * AUV_KeyManager.h
 * ---------------------------------------------------------------------------
 * Key model
 *   - Every UART link has TWO independent 256-bit keys, one per direction:
 *       txKey : localId -> peerId
 *       rxKey : peerId  -> localId
 *   - Every device pair has its own keys. The Thruster node only holds the
 *     Thruster<->Master keys, so stealing a Thruster board exposes only that
 *     one link, not the Sensor/IMU/Jetson links.
 *   - Keys are random (generated by tools/gen_keys.py with Python's
 *     `secrets` module) and placed in a per-node file AUV_Keys_Secret.h that
 *     lives in the sketch folder and must NEVER be committed or shared.
 *     The library itself contains no production keys.
 *
 * This header provides:
 *   - AUV_LinkKeys            : the key material for one link
 *   - AUV_validateLinkKeys()  : rejects zero / repeated / identical / demo keys
 *   - AUV_keyFingerprint()    : 32-bit one-way fingerprint for logs (never
 *                               print the key itself)
 *   - AUV_demoLinkKeys()      : PUBLIC bench-test keys (refused by default)
 * ---------------------------------------------------------------------------
 */
#ifndef AUV_KEY_MANAGER_H
#define AUV_KEY_MANAGER_H

#include <string.h>
#include <SHA256.h>          /* Crypto library by Rhys Weatherley */
#include "AUV_SecurityConfig.h"
#include "AUV_Packet.h"

struct AUV_LinkKeys {
    uint8_t localId;                 /* this device */
    uint8_t peerId;                  /* the device at the other end of the UART */
    uint8_t txKey[AUV_KEY_SIZE];     /* encrypts localId -> peerId */
    uint8_t rxKey[AUV_KEY_SIZE];     /* decrypts peerId -> localId */
};

/* Constant-time comparison (no early exit) */
inline bool AUV_ctEqual(const uint8_t *a, const uint8_t *b, size_t n) {
    uint8_t d = 0;
    for (size_t i = 0; i < n; i++) d |= (uint8_t)(a[i] ^ b[i]);
    return d == 0;
}

/* Deterministic PUBLIC demo key for direction src->dst. Only for bench tests.
 * Anyone can compute these, so they give no security at all. */
inline void AUV_demoKey(uint8_t src, uint8_t dst, uint8_t out[AUV_KEY_SIZE]) {
    SHA256 h;
    static const char label[] = "AUV-DEMO-KEY-NOT-SECRET-v1";
    h.update(label, sizeof(label) - 1);
    h.update(&src, 1);
    h.update(&dst, 1);
    h.finalize(out, AUV_KEY_SIZE);
    h.clear();
}

inline void AUV_demoLinkKeys(uint8_t localId, uint8_t peerId, AUV_LinkKeys &k) {
    k.localId = localId;
    k.peerId = peerId;
    AUV_demoKey(localId, peerId, k.txKey);
    AUV_demoKey(peerId, localId, k.rxKey);
}

inline bool AUV_isDemoKey(const uint8_t key[AUV_KEY_SIZE], uint8_t src, uint8_t dst) {
    uint8_t d[AUV_KEY_SIZE];
    AUV_demoKey(src, dst, d);
    bool same = AUV_ctEqual(key, d, AUV_KEY_SIZE);
    AUV_secureZero(d, sizeof(d));
    return same;
}

/* Reject keys that are obviously not random. This catches the most common
 * provisioning mistakes (empty array, copy-paste of one key into both
 * directions, placeholder 0x00/0xFF fill). It cannot prove randomness. */
inline bool AUV_keyLooksWeak(const uint8_t key[AUV_KEY_SIZE]) {
    uint8_t distinct[AUV_KEY_SIZE];
    uint8_t nd = 0;
    for (uint8_t i = 0; i < AUV_KEY_SIZE; i++) {
        bool seen = false;
        for (uint8_t j = 0; j < nd; j++) if (distinct[j] == key[i]) { seen = true; break; }
        if (!seen) distinct[nd++] = key[i];
    }
    AUV_secureZero(distinct, sizeof(distinct));
    /* 32 random bytes have ~24-28 distinct values; < 8 is never random */
    return nd < 8;
}

/* needTx / needRx: which keys this device actually uses on this link.
 * An encrypt-only node (Sensor, IMU) leaves rxKey all-zero; the Master's
 * receive-only side of that link leaves txKey all-zero. */
inline AUV_Status AUV_validateLinkKeys(const AUV_LinkKeys &k, bool needTx = true, bool needRx = true) {
    if (!AUV_isValidId(k.localId) || !AUV_isValidId(k.peerId)) return AUV_ERR_KEY_INVALID;
    if (k.localId == k.peerId)                                  return AUV_ERR_KEY_INVALID;
    if (!needTx && !needRx)                                     return AUV_ERR_KEY_INVALID;
    if (needTx && AUV_keyLooksWeak(k.txKey))                    return AUV_ERR_KEY_INVALID;
    if (needRx && AUV_keyLooksWeak(k.rxKey))                    return AUV_ERR_KEY_INVALID;
    if (needTx && needRx && AUV_ctEqual(k.txKey, k.rxKey, AUV_KEY_SIZE)) return AUV_ERR_KEY_INVALID;
#if !AUV_ALLOW_DEMO_KEYS
    if ((needTx && AUV_isDemoKey(k.txKey, k.localId, k.peerId)) ||
        (needRx && AUV_isDemoKey(k.rxKey, k.peerId, k.localId))) return AUV_ERR_DEMO_KEY_REFUSED;
#endif
    return AUV_OK;
}

/* 32-bit fingerprint of a key, safe to print: lets you check that both ends
 * of a link were built with the same key file without revealing the key. */
inline uint32_t AUV_keyFingerprint(const uint8_t key[AUV_KEY_SIZE]) {
    SHA256 h;
    uint8_t out[32];
    static const char label[] = "AUV-KEY-FINGERPRINT-v1";
    h.update(label, sizeof(label) - 1);
    h.update(key, AUV_KEY_SIZE);
    h.finalize(out, sizeof(out));
    h.clear();
    uint32_t fp = AUV_getU32(out);
    AUV_secureZero(out, sizeof(out));
    return fp;
}

#endif /* AUV_KEY_MANAGER_H */
